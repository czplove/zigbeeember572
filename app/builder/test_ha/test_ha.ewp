# IAR project test_ha.ewp, settings and files
configuration Normal (ARM, debug)
  General.OGChipSelectEditMenu: EFR32MG1P232F256GM48 SiliconLaboratories EFR32MG1P232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NULL_BTL; CORTEXM3; CORTEXM3_EFR32; CORTEXM3_EFR32_MICRO; CORTEXM3_EFM32_MICRO; PHY_EFR32; EFR32MG1P; EFR32MG1P232F256GM48; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/test_ha/test_ha_endpoint_config.h"; BOARD_HEADER="app\builder\test_ha\test_ha_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/test_ha/test_ha_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/test_ha/test_ha.h"; __SOURCEFILE__="$FILE_FNAME$"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\util; ..\..\..\app\framework\include; ..\..\..\stack; ..\..\..\hal; ..\..\..\hal\..; ..\..\..\submodules\Device\SiliconLabs\EFR32MG1P\Include; ..\..\..\submodules\CMSIS\Include; ..\..\..\submodules\emlib\inc; ..\..\..\submodules\emdrv\common\inc; ..\..\..\submodules\emdrv\rtcdrv\inc; ..\..\..\submodules\emdrv\sleep\inc; ..\..\..\submodules\emdrv\trace\inc; ..\..\..\submodules\emdrv\gpiointerrupt\inc; ..\..\..\submodules\emdrv\ecode; ..\..\..\submodules\emdrv\uartdrv\inc; ..\..\..\submodules\emdrv\spidrv\inc; ..\..\..\submodules\emdrv\dmadrv\inc; ..\..\..\submodules\emdrv\ustimer\inc; ..\..\..\submodules\emdrv\rtcdrv\inc; ..\..\..\submodules\kits\common\bsp\; ..\..\..\submodules\emdrv\gpiointerrupt\inc\; ..\..\..\submodules\emdrv\uartdrv\inc\; ..\..\..\submodules\emdrv\ustimer\inc\; ..\..\..\submodules\emdrv\rtcdrv\inc\; ..\..\..\submodules\emdrv\common\inc\; ..\..\..\hal\micro\cortexm3\efm32\config\; ..\..\..\submodules\emdrv\dmadrv\inc\; ..\..\..\submodules\emdrv\trace\inc\; ..\..\..\submodules\emdrv\tempdrv\inc; ..\..\..\hal\micro\cortexm3\efm32\efr32; ..\..\..\hal\micro\cortexm3\efm32; ..\..\..\submodules\efrseq\rfprotocol\ieee802154\cortex; ..\..\..\submodules\efrseq\common\cortex; ..\..\..\submodules\s029_efr4fpga_drv\inc; ..\..\..\submodules\reptile\glib; ..\..\..\submodules\reptile\glib\glib; ..\..\..\submodules\kits\common\bsp; ..\..\..\submodules\kits\EFR32MG1_BRD4151A\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: NULL_BTL; CORTEXM3; CORTEXM3_EFM32_MICRO; CORTEXM3_EFR32_MICRO; CORTEXM3_EFR32; PHY_EFR32; EFR32MG1P; EFR32MG1P232F256GM48; APPLICATION_TOKEN_HEADER="app/framework/util/tokens.h"; ATTRIBUTE_STORAGE_CONFIGURATION="app/builder/test_ha/test_ha_endpoint_config.h"; BOARD_HEADER="app\builder\test_ha\test_ha_board.h"; CONFIGURATION_HEADER="app/framework/util/config.h"; GENERATED_TOKEN_HEADER="app/builder/test_ha/test_ha_tokens.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar.h"; ZA_GENERATED_HEADER="app/builder/test_ha/test_ha.h"; EMBER_AF_API_EMBER_TYPES="stack/include/ember-types.h"
  AARM.AUserIncludes: $FILE_DIR$; $PROJ_DIR$; ..\..\..; ..\..\..\app\util; ..\..\..\app\framework\include; ..\..\..\stack; ..\..\..\hal; ..\..\..\hal\..; ..\..\..\submodules\kits\common\bsp; ..\..\..\submodules\kits\EFR32MG1_BRD4151A\config
  OBJCOPY.OOCOutputFile: test_ha.s37
  postbuild: test_ha.bat $TARGET_BPATH$ \..\..\..
  ILINK.IlinkOutputFile: test_ha.out
  ILINK.IlinkConfigDefines: NULL_BTL=1
  ILINK.IlinkIcfFile: ..\..\..\hal\micro\cortexm3\efm32\efr32\iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../app/builder/test_ha/: test_ha_callbacks.c
    ../../../app/framework/plugin/address-table/: address-table.c address-table-cli.c
    ../../../app/framework/plugin/counters/: counters-cli.c counters-ota.c counters-soc.c
    ../../../app/framework/plugin/door-lock-server/: door-lock-server.c
    ../../../app/util/serial/: ember-printf.c
    ../../../app/framework/plugin/end-device-support/: end-device-support.c end-device-move.c end-device-support-cli.c polling-common.c polling-soc.c
    ../../../app/framework/plugin/form-and-join/: form-and-join-afv2.c
    ../../../app/util/common/: form-and-join.c form-and-join-node-adapter.c
    ../../../app/framework/plugin/groups-server/: groups-server.c groups-server-cli.c
    ../../../app/framework/plugin/heartbeat/: heartbeat.c
    ../../../app/framework/plugin/identify/: identify.c identify-cli.c
    ../../../app/framework/plugin/identify-feedback/: identify-feedback.c
    ../../../app/framework/plugin/network-find/: network-find.c
    ../../../app/framework/plugin/scan-dispatch/: scan-dispatch.c
    ../../../app/framework/plugin/scenes/: scenes.c scenes-cli.c
    ../../../app/framework/plugin/simple-main/: simple-main.c
    ../../../app/framework/plugin-soc/idle-sleep/: idle-sleep.c idle-sleep-cli.c idle-sleep-soc.c
    ../../../hal/micro/generic/: antenna-stub.c sim-eeprom.c crc.c endian.c mem-util.c random.c
    ./: call-command-handler.c callback-stub.c stack-handler-stub.c cli.c
    ../../../hal/micro/cortexm3/efm32/: adc.c assert-crash-handlers.c button.c buzzer.c cstartup-common.c diagnostic.c faults.s79 isr-stubs.s79 led.c mfg-token.c micro-common.c micro.c mpu.c sleep-efm32.c token-def.c token.c ext-device.c
    ../../framework/util/: af-event.c af-main-common.c af-main-soc.c attribute-size.c attribute-storage.c attribute-table.c client-api.c print.c print-formatter.c process-cluster-message.c process-global-message.c service-discovery-common.c service-discovery-soc.c message.c multi-network.c time-util.c util.c
    ../../framework/security/: af-node.c af-security-common.c af-trust-center.c crypto-state.c
    ../../util/serial/: command-interpreter2.c serial.c com.c
    ../../../hal/: ember-configuration.c
    ../../../build/hal-library-cortexm3-iar-efr32mg1p-efr32/: hal-library.a
    ../../../submodules/kits/common/bsp/: bsp_stk_leds.c
    ../../util/common/: library.c
    ../../framework/cli/: core-cli.c network-cli.c option-cli.c plugin-cli.c security-cli.c zcl-cli.c zdo-cli.c
    ../../util/security/: security-address-cache.c
    ../../util/zigbee-framework/: zigbee-device-common.c zigbee-device-library.c
  group emdrv
    ../../../submodules/emdrv/dmadrv/src/: dmadrv.c
    ../../../submodules/emdrv/gpiointerrupt/src/: gpiointerrupt.c
    ../../../submodules/emdrv/rtcdrv/src/: rtcdriver.c
    ../../../submodules/emdrv/sleep/src/: sleep.c
    ../../../submodules/emdrv/tempdrv/src/: tempdrv.c
    ../../../submodules/emdrv/trace/src/: trace.c
    ../../../submodules/emdrv/uartdrv/src/: uartdrv.c
    ../../../submodules/emdrv/ustimer/src/: ustimer.c
  group emlib
    ../../../submodules/emlib/src/: em_adc.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_leuart.c em_mpu.c em_msc.c em_prs.c em_rmu.c em_rtcc.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../submodules/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
  group Libraries
    ../../../build/alarm-stub-library-cortexm3-iar-efr32mg1p-efr32/: alarm-stub-library.a
    ../../../build/binding-table-library-cortexm3-iar-efr32mg1p-efr32/: binding-table-library.a
    ../../../build/cbke-163k1-stub-library-cortexm3-iar-efr32mg1p-efr32/: cbke-163k1-stub-library.a
    ../../../build/cbke-283k1-stub-library-cortexm3-iar-efr32mg1p-efr32/: cbke-283k1-stub-library.a
    ../../../build/cbke-stub-library-cortexm3-iar-efr32mg1p-efr32/: cbke-stub-library.a
    ../../../build/cbke-library-dsa-sign-stub-cortexm3-iar-efr32mg1p-efr32/: cbke-library-dsa-sign-stub.a
    ../../../build/cbke-library-dsa-verify-stub-cortexm3-iar-efr32mg1p-efr32/: cbke-library-dsa-verify-stub.a
    ../../../build/cbke-library-dsa-verify-283k1-stub-cortexm3-iar-efr32mg1p-efr32/: cbke-library-dsa-verify-283k1-stub.a
    ../../../build/debug-basic-library-cortexm3-iar-efr32mg1p-efr32/: debug-basic-library.a
    ../../../build/debug-extended-stub-library-cortexm3-iar-efr32mg1p-efr32/: debug-extended-stub-library.a
    ../../../build/end-device-bind-stub-library-cortexm3-iar-efr32mg1p-efr32/: end-device-bind-stub-library.a
    ../../../build/enhanced-beacon-request-stub-library-cortexm3-iar-efr32mg1p-efr32/: enhanced-beacon-request-stub-library.a
    ../../../build/gp-stub-library-cortexm3-iar-efr32mg1p-efr32/: gp-stub-library.a
    ../../../build/install-code-library-stub-cortexm3-iar-efr32mg1p-efr32/: install-code-library-stub.a
    ../../../build/multi-network-stub-library-cortexm3-iar-efr32mg1p-efr32/: multi-network-stub-library.a
    ../../../build/packet-validate-library-cortexm3-iar-efr32mg1p-efr32/: packet-validate-library.a
    ../../../build/rf4ce-stack-stub-library-cortexm3-iar-efr32mg1p-efr32/: rf4ce-stack-stub-library.a
    ../../../build/security-library-core-cortexm3-iar-efr32mg1p-efr32/: security-library-core.a
    ../../../build/security-library-link-keys-stub-cortexm3-iar-efr32mg1p-efr32/: security-library-link-keys-stub.a
    ../../../build/zigbee-pro-stack-cortexm3-iar-efr32mg1p-efr32/: zigbee-pro-stack.a
    ../../../build/zll-stub-library-cortexm3-iar-efr32mg1p-efr32/: zll-stub-library.a
    ../../../build/hal-library-cortexm3-iar-efr32mg1p-efr32/: hal-library.a
    ../../../build/sim-eeprom1-library-cortexm3-iar-efr32mg1p-efr32/: sim-eeprom1-library.a
