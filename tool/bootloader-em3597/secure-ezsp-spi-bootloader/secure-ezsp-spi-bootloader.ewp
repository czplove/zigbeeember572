# IAR project secure-ezsp-spi-bootloader.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/ncp_spi_em359x.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3597; PHY_NULL; BOARD_NCP_SPI; CORTEXM3_EMBER_MICRO; BTL_HAS_EZSP_SPI; DISABLE_IDLING_DELAY; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_EZSP_SPI; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ../../../app/util; ../../../hal/micro/cortexm3/common; ../../../lwip/; ../../../lwip/src/include/; ../../../lwip/contrib/port/FreeRTOS/EM358X/; ../../../lwip/src/include/ipv4/; ../../../lwip/src/include/ipv6/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/ncp_spi_em359x.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3597; PHY_NULL; BOARD_NCP_SPI; CORTEXM3_EMBER_MICRO; BTL_HAS_EZSP_SPI; DISABLE_IDLING_DELAY; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_EZSP_SPI
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: secure-ezsp-spi-bootloader.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: secure-ezsp-spi-bootloader.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1; FLASH_SIZE=256K; RAM_SIZE=32K
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3597/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/bootloader/: bootloader-gpio-ezsp-spi.c btl-ezsp-spi-device.c cstartup-iar-boot.c cstartup-iar-boot-entry.s79
    ../../../hal/micro/cortexm3/common/: btl-ezsp-spi.c btl-ezsp-spi-protocol.c
    ../../../hal/micro/generic/: crc.c mem-util.c random.c
    ../../../hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../build/secure-ezsp-spi-bootloader-library-cortexm3-iarboot-em3597-null/: secure-ezsp-spi-bootloader-library.a
