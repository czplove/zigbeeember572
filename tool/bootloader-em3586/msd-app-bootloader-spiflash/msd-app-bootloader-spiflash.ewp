# IAR project msd-app-bootloader-spiflash.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3586; PHY_NULL; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; SPI_FLASH_SC1; MSD_BOOTLOADER; EEPROM_USES_SHUTDOWN_CONTROL; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI; USB_MSD; BOOTLOADER_USB; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ../../../app/util; ../../../hal/micro/cortexm3/common; ../../../lwip/; ../../../lwip/src/include/; ../../../lwip/contrib/port/FreeRTOS/EM358X/; ../../../lwip/src/include/ipv4/; ../../../lwip/src/include/ipv6/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/em35x/board/dev0680etm.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EM3586; PHY_NULL; BOARD_DEV0680ETM; CORTEXM3_EMBER_MICRO; BTL_HAS_SERIAL; BOOTLOADER; SPI_FLASH_SC1; MSD_BOOTLOADER; EEPROM_USES_SHUTDOWN_CONTROL; BOOTLOADER_TYPE=BL_EXT_TYPE_APP_SPI; USB_MSD; BOOTLOADER_USB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: msd-app-bootloader-spiflash.s37
  postbuild: "$_ISA3_UTILS_DIR_$\em3xx_convert.exe" "$TARGET_BPATH$.s37" "$TARGET_BPATH$.ebl"
  ILINK.IlinkOutputFile: msd-app-bootloader-spiflash.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1; FLASH_SIZE=256K; RAM_SIZE=32K
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/em35x/em3586/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/cortexm3/common/: app-bootloader-custom.c spiflash-class1.c
    ../../../hal/micro/cortexm3/bootloader/: app-bootloader-em3xx.c bootloader-gpio.c cstartup-iar-boot.c cstartup-iar-boot-entry.s79 spiflash-low-level.c
    ../../../hal/micro/generic/: crc.c mem-util.c random.c
    ../../../hal/micro/cortexm3/usb/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbhal.c em_usbint.c em_usbtimer.c
    ../../../hal/micro/cortexm3/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../build/msd-app-bootloader-library-cortexm3-iarboot-em3586-null/: msd-app-bootloader-library.a
    ../../../hal/micro/cortexm3/usb/msd/: msdd.c msddmedia.c
