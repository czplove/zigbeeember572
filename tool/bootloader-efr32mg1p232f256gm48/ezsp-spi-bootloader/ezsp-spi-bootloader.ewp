# IAR project ezsp-spi-bootloader.ewp, settings and files
configuration Normal (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFR32MG1P133F256GM48 SiliconLaboratories EFR32MG1P133F256GM48
  ICCARM.CCDefines: BOARD_HEADER="hal/micro/cortexm3/efm32/board/brd4151a.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EFR32; PHY_NULL; BOARD_BRD4151A; CORTEXM3_EFM32_MICRO; EFR32MG1P232F256GM48; EFR32MG1P; CORTEXM3_EFR32_MICRO; AESDRV_HWACCEL_DMA_ENABLED=false; RTCDRV_USE_LFRCO; BTL_HAS_EZSP_SPI; DISABLE_IDLING_DELAY; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_EZSP_SPI; EM_MSC_RUN_FROM_FLASH; __SOURCEFILE__="$FILE_FNAME$"
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros; --separate_cluster_for_initialized_variables
  ICCARM.CCIncludePath2: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ../../../app/util; ../../../hal/micro/cortexm3/efm32/config; ../../../submodules/emdrv/common/inc; ../../../submodules/emdrv/rtcdrv/inc; ../../../submodules/emdrv/sleep/inc; ../../../submodules/emdrv/aesdrv/inc; ../../../submodules/emdrv/aesdrv/src; ../../../submodules/emdrv/trace/inc; ../../../submodules/emdrv/gpiointerrupt/inc; ../../../submodules/emdrv/ecode; ../../../submodules/emdrv/uartdrv/inc; ../../../submodules/emdrv/spidrv/inc; ../../../submodules/emdrv/dmadrv/inc; ../../../submodules/emdrv/ustimer/inc; ../../../submodules/emdrv/cryptodrv/src; ../../../submodules/emdrv/tempdrv/inc; ../../../hal/micro/cortexm3/common; ../../../submodules/emlib/inc; ../../../submodules/emdrv/rtcdrv/inc; ../../../submodules/CMSIS/Include; ../../../submodules/kits/common/bsp; ../../../submodules/kits/common/drivers; ../../../hal/micro/cortexm3/efm32; ../../../hal/micro/cortexm3/efm32/efr32; ../../../submodules/reptile/glib; ../../../submodules/reptile/glib/glib; ../../../submodules/reptile/glib/dmd; ../../../submodules/Device/SiliconLabs/EFR32MG1P/Include; ../../../submodules/kits/EFR32MG1_BRD4151A/config; ../../../lwip/; ../../../lwip/src/include/; ../../../lwip/contrib/port/FreeRTOS/EM358X/; ../../../lwip/src/include/ipv4/; ../../../lwip/src/include/ipv6/
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.ADefines: BOARD_HEADER="hal/micro/cortexm3/efm32/board/brd4151a.h"; PLATFORM_HEADER="hal/micro/cortexm3/compiler/iar-boot.h"; HAL_MICRO; CORTEXM3; CORTEXM3_EFR32; PHY_NULL; BOARD_BRD4151A; CORTEXM3_EFM32_MICRO; EFR32MG1P232F256GM48; EFR32MG1P; CORTEXM3_EFR32_MICRO; AESDRV_HWACCEL_DMA_ENABLED=false; RTCDRV_USE_LFRCO; BTL_HAS_EZSP_SPI; DISABLE_IDLING_DELAY; BOOTLOADER; BOOTLOADER_TYPE=BL_EXT_TYPE_EZSP_SPI; EM_MSC_RUN_FROM_FLASH
  AARM.AUserIncludes: $FILE_DIR$\; ..\..\..\; ..\..\..\STACK\; ..\..\..\HAL\; ..\..\..\; ..\..\..\rtos\FreeRTOS\; ..\..\..\rtos\FreeRTOS\Source\; ..\..\..\rtos\FreeRTOS\Source\include; ..\..\..\rtos\FreeRTOS\Source\portable\IAR\ARM_CM3
  OBJCOPY.OOCOutputFile: ezsp-spi-bootloader.bin
  postbuild: "ielftool.exe" "$TARGET_BPATH$.out" "$TARGET_BPATH$.s37" --srec --srec-s3only
  ILINK.IlinkOutputFile: ezsp-spi-bootloader.out
  ILINK.IlinkConfigDefines: BOOTLOADER=1; FLASH_SIZE=256K; RAM_SIZE=32K
  ILINK.IlinkIcfFile: ../../../hal/micro/cortexm3/efm32/efr32/iar-cfg.icf
  ILINK.IlinkProgramEntryLabel: halEntryPoint
  group (top)
    ../../../hal/micro/generic/: antenna-stub.c crc.c mem-util.c random.c
    ../../../hal/micro/cortexm3/efm32/bootloader/: bootloader-gpio-ezsp-spi.c btl-ezsp-spi-device.c cstartup-iar-boot.c cstartup-iar-boot-entry.s79
    ../../../submodules/kits/common/bsp/: bsp_stk.c bsp_stk_leds.c
    ../../../hal/micro/cortexm3/common/: btl-ezsp-spi.c btl-ezsp-spi-protocol.c
    ../../../submodules/emlib/src/: em_assert.c em_cmu.c em_emu.c em_gpio.c em_int.c em_ldma.c em_msc.c em_rmu.c em_system.c em_timer.c em_usart.c em_wdog.c
    ../../../build/ezsp-spi-bootloader-library-cortexm3-iarboot-efr32mg1p-null/: ezsp-spi-bootloader-library.a
    ../../../hal/micro/cortexm3/efm32/: isr-stubs.s79 led.c mfg-token.c micro-common.c
    ../../../submodules/Device/SiliconLabs/EFR32MG1P/Source/: system_efr32mg1p.c
    ../../../submodules/emdrv/ustimer/src/: ustimer.c
